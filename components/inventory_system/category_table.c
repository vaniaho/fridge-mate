#include "category_table.h"
#include <string.h>

// ======== 品类知识库 ========
// 结构：{关键词, 分类名}，匹配规则为子串包含

typedef struct {
    const char* keyword;
    const char* category;
} category_entry_t;

// 分类映射表 —— 关键词 → 分类
// 优先匹配更具体的关键词（长关键词排在前面）
static const category_entry_t CATEGORY_MAP[] = {
    // 水果
    {"苹果",   "水果"}, {"香蕉",   "水果"}, {"橙子",   "水果"}, {"橘子",   "水果"},
    {"葡萄",   "水果"}, {"草莓",   "水果"}, {"蓝莓",   "水果"}, {"樱桃",   "水果"},
    {"西瓜",   "水果"}, {"桃子",   "水果"}, {"梨",     "水果"}, {"芒果",   "水果"},
    {"猕猴桃", "水果"}, {"柠檬",   "水果"}, {"火龙果", "水果"}, {"榴莲",   "水果"},
    {"荔枝",   "水果"}, {"龙眼",   "水果"}, {"柿子",   "水果"}, {"哈密瓜", "水果"},
    {"山竹",   "水果"}, {"石榴",   "水果"}, {"杨梅",   "水果"}, {"枇杷",   "水果"},

    // 蔬菜
    {"西红柿", "蔬菜"}, {"番茄",   "蔬菜"}, {"黄瓜",   "蔬菜"}, {"土豆",   "蔬菜"},
    {"白菜",   "蔬菜"}, {"青菜",   "蔬菜"}, {"菠菜",   "蔬菜"}, {"生菜",   "蔬菜"},
    {"芹菜",   "蔬菜"}, {"茄子",   "蔬菜"}, {"辣椒",   "蔬菜"}, {"青椒",   "蔬菜"},
    {"洋葱",   "蔬菜"}, {"大蒜",   "蔬菜"}, {"姜",     "蔬菜"}, {"胡萝卜", "蔬菜"},
    {"白萝卜", "蔬菜"}, {"南瓜",   "蔬菜"}, {"冬瓜",   "蔬菜"}, {"豆角",   "蔬菜"},
    {"西兰花", "蔬菜"}, {"花菜",   "蔬菜"}, {"蘑菇",   "蔬菜"}, {"香菇",   "蔬菜"},
    {"韭菜",   "蔬菜"}, {"莲藕",   "蔬菜"}, {"玉米",   "蔬菜"}, {"毛豆",   "蔬菜"},
    {"山药",   "蔬菜"}, {"紫菜",   "蔬菜"}, {"木耳",   "蔬菜"},

    // 肉禽
    {"猪肉",   "肉禽"}, {"牛肉",   "肉禽"}, {"牛腩",   "肉禽"}, {"羊肉",   "肉禽"},
    {"鸡肉",   "肉禽"}, {"鸡翅",   "肉禽"}, {"鸡腿",   "肉禽"}, {"鸡胸",   "肉禽"},
    {"鸭肉",   "肉禽"}, {"排骨",   "肉禽"}, {"五花肉", "肉禽"}, {"里脊",   "肉禽"},
    {"肉末",   "肉禽"}, {"肉丝",   "肉禽"}, {"肉片",   "肉禽"}, {"培根",   "肉禽"},
    {"火腿",   "肉禽"}, {"香肠",   "肉禽"}, {"腊肉",   "肉禽"},

    // 海鲜水产
    {"虾",     "海鲜"}, {"虾仁",   "海鲜"}, {"鱼",     "海鲜"}, {"三文鱼", "海鲜"},
    {"带鱼",   "海鲜"}, {"鲫鱼",   "海鲜"}, {"螃蟹",   "海鲜"}, {"蛤蜊",   "海鲜"},
    {"鱿鱼",   "海鲜"}, {"扇贝",   "海鲜"}, {"生蚝",   "海鲜"}, {"海带",   "海鲜"},

    // 蛋奶
    {"鸡蛋",   "蛋奶"}, {"鸭蛋",   "蛋奶"}, {"鹌鹑蛋", "蛋奶"},
    {"牛奶",   "蛋奶"}, {"酸奶",   "蛋奶"}, {"奶酪",   "蛋奶"}, {"黄油",   "蛋奶"},
    {"奶油",   "蛋奶"}, {"炼乳",   "蛋奶"},

    // 豆制品
    {"豆腐",   "豆制品"}, {"豆浆",   "豆制品"}, {"豆干",   "豆制品"},
    {"腐竹",   "豆制品"}, {"豆皮",   "豆制品"}, {"纳豆",   "豆制品"},

    // 主食
    {"米饭",   "主食"}, {"面条",   "主食"}, {"面粉",   "主食"}, {"馒头",   "主食"},
    {"饺子",   "主食"}, {"包子",   "主食"}, {"年糕",   "主食"}, {"粉丝",   "主食"},
    {"燕麦",   "主食"}, {"面包",   "主食"}, {"吐司",   "主食"}, {"挂面",   "主食"},

    // 调味品
    {"酱油",   "调味品"}, {"醋",     "调味品"}, {"盐",     "调味品"},
    {"糖",     "调味品"}, {"味精",   "调味品"}, {"鸡精",   "调味品"},
    {"料酒",   "调味品"}, {"蚝油",   "调味品"}, {"豆瓣酱", "调味品"},
    {"番茄酱", "调味品"}, {"辣椒酱", "调味品"}, {"花椒",   "调味品"},
    {"八角",   "调味品"}, {"桂皮",   "调味品"}, {"淀粉",   "调味品"},

    // 饮品
    {"可乐",   "饮品"}, {"果汁",   "饮品"}, {"矿泉水", "饮品"},
    {"啤酒",   "饮品"}, {"茶",     "饮品"}, {"咖啡",   "饮品"},

    // 零食
    {"饼干",   "零食"}, {"薯片",   "零食"}, {"巧克力", "零食"},
    {"坚果",   "零食"}, {"花生",   "零食"}, {"瓜子",   "零食"},

    // 冻品
    {"速冻",   "冻品"}, {"冰淇淋", "冻品"}, {"雪糕",   "冻品"},
    {"冻虾",   "冻品"}, {"冻肉",   "冻品"},

    {NULL, NULL} // 哨兵，标记表结束
};

// ======== 分类 → 默认保质期映射 ========

typedef struct {
    const char* category;
    int expire_days;
} expire_entry_t;

static const expire_entry_t EXPIRE_MAP[] = {
    {"水果",   7},
    {"蔬菜",   5},
    {"肉禽",   3},
    {"海鲜",   2},
    {"蛋奶",   14},
    {"豆制品", 3},
    {"主食",   30},
    {"调味品", 180},
    {"饮品",   90},
    {"零食",   90},
    {"冻品",   90},
    {"其他",   7},
    {NULL, 0}
};

// ======== 接口实现 ========

const char* category_lookup(const char* name) {
    if (!name || name[0] == '\0') return "其他";

    for (int i = 0; CATEGORY_MAP[i].keyword != NULL; i++) {
        if (strstr(name, CATEGORY_MAP[i].keyword) != NULL) {
            return CATEGORY_MAP[i].category;
        }
    }

    return "其他";
}

int default_expire_days(const char* category) {
    if (!category || category[0] == '\0') return 7;

    for (int i = 0; EXPIRE_MAP[i].category != NULL; i++) {
        if (strcmp(category, EXPIRE_MAP[i].category) == 0) {
            return EXPIRE_MAP[i].expire_days;
        }
    }

    return 7; // 未知分类默认 7 天
}

int expire_days_for_item(const char* name) {
    const char* cat = category_lookup(name);
    return default_expire_days(cat);
}
